# Keil uVision project X_Infantry.uvprojx, settings and files
target X_Infantry (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: X_Infantry
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ../Inc;                                                  ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                                                  ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                                  ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;                                                  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                  ../Middlewares/Third_Party/FreeRTOS/Source/include;                                                  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                                  ../Drivers/CMSIS/Include;                                                  ..\Framework;                                                  ..\Framework\utilities;                                                  ..\Framework\rtos;                                                  ..\Framework\drivers;                                                  ..\Framework\applications;                                                  ..\Framework\peripheral
  asm include: ..\Inc;..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
    ..//Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Framework/RTOS
    ../Framework/rtos/: rtos_init.c rtos_init.h rtos_semaphore.c rtos_semaphore.h rtos_task.c rtos_task.h
  group Framework/Peripheral
    ../Framework/peripheral/: peripheral_define.h peripheral_can.c peripheral_can.h peripheral_gpio.c peripheral_gpio.h peripheral_spi.c peripheral_spi.h peripheral_usart.c peripheral_usart.h peripheral_tim.h peripheral_laser.h
  group Framework/Utilities
    ../Framework/utilities/: utilities_debug.c utilities_debug.h utilities_iopool.c utilities_iopool.h utilities_minmax.h utilities_tim.c utilities_tim.h
    ../Framework/peripheral/: peripheral_tim.c
  group Framework/Drivers
    ../Framework/drivers/: drivers_led.c drivers_led_low.h drivers_led_user.h drivers_imu.c drivers_imu_mpu6500_reg.h drivers_imu_IST8310_reg.h drivers_imu_low.h drivers_imu_user.h drivers_buzzer_low.h drivers_buzzer_user.h drivers_buzzer_notes.h drivers_buzzer_music.h drivers_buzzer.c drivers_canmotor.c drivers_canmotor_low.h drivers_canmotor_user.h drivers_uart.h drivers_uart.c drivers_uartrc.c drivers_uartrc_low.h drivers_uartrc_user.h drivers_uartupper.c drivers_uartupper_low.h drivers_uartupper_user.h drivers_flash.c drivers_flash.h drivers_sonar.c drivers_sonar_low.h drivers_sonar_user.h drivers_ramp.h RMLib.lib pid_regulator.h pid_regulator.c pwm_server_ motor.c pwm_server_motor.h drivers_uartjudge.c drivers_uartjudge_low.h drivers_platemotor.c drivers_platemotor.h drivers_cmpower.c drivers_cmpower.h drivers_servo.c drivers_servo.h drivers_uartgyro.c drivers_uartgyro_low.h drivers_uartgyro_user.h
  group Framework/Applications
    ../Framework/applications/: tasks_motor.c tasks_motor.h application_motorcontrol.c application_motorcontrol.h tasks_upper.c tasks_upper.h application_quaternion.c application_quaternion.h tasks_remotecontrol.c tasks_remotecontrol.h tasks_timed.c tasks_timed.h application_waveform.c application_waveform.h tasks_platemotor.c tasks_platemotor.h platemotor.c platemotor.h
  group Application/User
    ../Src/: main.c gpio.c adc.c can.c dma.c freertos.c iwdg.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c
software components: CMSIS:CORE 4.1.0
